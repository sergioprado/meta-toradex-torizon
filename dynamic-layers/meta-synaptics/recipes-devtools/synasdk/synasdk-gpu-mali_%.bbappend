PREBUILT_LIBS = "sysroot/linux-baseline/data/gfx_prebuilt/mali/${DISPLAY_SERVER}/${SYNAMACH}/aarch64-poky-linux/lib/"
PREBUILT_BINS = "sysroot/linux-baseline/data/gfx_prebuilt/mali/${DISPLAY_SERVER}/${SYNAMACH}/aarch64-poky-linux/bin/"
